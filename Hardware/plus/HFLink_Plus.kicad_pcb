# Repository LX050724/HFLink

File readme.md:

# HFLink

完全使用FPGA实现的高速DAP

## 硬件能力：

|                                 | HFLink Plus        | 敬请期待 |
| ------------------------------- | ------------------ | -------- |
| **硬件规格：**                  |                    |          |
| **Power supply**                | USB                |          |
| **Download speed into RAM**     | 3867KB/s@60MHz SWD |          |
| **Max. target interface speed** | 60MHz              |          |
| **Max. SWO speed** | 100MHz | |
| **Max. VCOM speed/baudrate**    | 15 MBd             |          |
| **Max. SPI interface speed** | 30MHz | |
| **Supported target voltage**    | 1.65 V - 5 V        |          |
| **Ethernet**                    | ❌️                  |          |
| **USB**                         | ✅️                  |          |
| **WiFi**                        | ❌️                  |          |
| **目标接口：**                  |                    |          |
| **SWD**                         | ✅️                  |          |
| **JTAG**                        | ✅️                  |          |
| **VCOM**                        | ✅️                  |          |

## SWD/JTAG:

最大时钟60MHz，时钟连续均匀，支持时序延迟补偿，带宽接近理论最大值

注：逻辑分析仪触发电平和采样率问题导致占空比和频率显示有微小偏差

## LED:

支持两种模式可在上位机随意切换

- 默认模式
  1. 红色：目标电压低
  2. 绿色：目标电压正常
  3. 黄色：复位信号低
  4. 熄灭/不规律闪烁：DAP正在执行命令，熄灭时间表示执行时间
- CMSIS-DAP模式
  1. 绿色：空闲
  2. 蓝色：已连接
  3. 紫色：运行中

## SWO:

四倍过采样最高100M波特率，使用跳变沿对齐时间极大提高波特率误差容忍

NRZ模式支持小数分频，波特率计算公式 `3200M/n (n>=32)`

Manchester支持大容差无需小数分频，波特率计算公式`200M/n (n>=2)`

## TODO：

- VTRG电压&5V电流读取 ⬅️需开发上位机
- SPI ⬅️需开发上位机
- 线路延迟自标定⬅️需开发上位机

## 构建&下载方法：

1. 打开高云FPGA工程，调整include路径配置
2. 重新生成M1 IP核，其他IP核不需要生成
3. 综合生成FPGA比特流
4. 编译MCU代码自动生成合并MCU程序的比特流文件`bitstream.bin`
5. 高云下载器设置`Debugging/Temporary Mode` -> `Set ExFlash QE For Arora V`使能Flash的Quad模式（仅需一次）
6. 高云下载器设置`External Flash Mode Arora V` -> `exFlash Erase,Program,Verify Arora V`进行外部Flash下载

## KiCad design Hardware/plus/HFLink_Plus.kicad_pcb

Parts:
H1, H2, H3, H4: MountingHole_Pad; MountingHole_2.2mm_M2_ISO7380_Pad_TopBottom

Connections:
GND: H1.1, H2.1, H3.1, H4.1; also elsewhere on the board

Parts:
D4, D5: NCD0603G1; LED_0603_1608Metric
D6: LED_RGBA; LED_RGBA_1615
FB1, FB2, FB3: 600Ω@100MHz; L_0402_1005Metric
J1, J2: DF40C-60DS-0.4V(51); BTB-DF40C-60DS-0.4V(51)#
J6: Conn_01x08_Pin; PinHeader_1x08_P1.27mm_Vertical
R6: 5.1K,1%; R_0402_1005Metric
R34, R35: 10K,1%; R_0402_1005Metric
R36, R37, R38: 1K,1%; R_0402_1005Metric
TP1, TP2, TP3, TP4, TP5, TP6, TP7, TP8, TP9, TP10, TP11, TP12, TP13, TP14: test_point_0.5mm

Connections:
+1V8: FB3.2, J2.38, J2.40; also elsewhere on the board
+3V3: D6.4 (A), FB1.2, FB2.2, J2.46, J2.48, J2.50, J6.5; also elsewhere on the board
+5V: J2.52, J2.54, J2.56, J2.58, J2.60; also elsewhere on the board
/GW5A_LV25MG121N/A1_IOB24A_40P: J2.11
/GW5A_LV25MG121N/A2_JTAG_TDO: J2.25, J6.3
/GW5A_LV25MG121N/A3_JTAG_TDI: J2.27, J6.4
/GW5A_LV25MG121N/A10_IOL14B: J1.58
/GW5A_LV25MG121N/A11_IOL14A: J1.56
/GW5A_LV25MG121N/B1_JTAG_TMS: J2.23, J6.2
/GW5A_LV25MG121N/B2_IOB4A_40P: J2.3
/GW5A_LV25MG121N/B3_IOB56A: J1.19
/GW5A_LV25MG121N/B10_IOL12B: J1.57
/GW5A_LV25MG121N/B11_IOL12A: J1.55
/GW5A_LV25MG121N/C1_JTAG_TCK: J2.21, J6.1, R6.1
/GW5A_LV25MG121N/C2_IOB4B_40P: J2.5
/GW5A_LV25MG121N/C3_IOB56B: J1.21
/GW5A_LV25MG121N/C10_IOL5B: J1.53
/GW5A_LV25MG121N/C11_IOL5A: J1.51
/GW5A_LV25MG121N/D1_IOB14B_40P: J2.17
/GW5A_LV25MG121N/D7_DONE: J1.25, R34.2
/GW5A_LV25MG121N/D8_RECONFIG: J2.13
/GW5A_LV25MG121N/D10_IOL9B: J1.49
/GW5A_LV25MG121N/D11_IOL9A: J1.47
/GW5A_LV25MG121N/DBGIO.PWR: J2.32, TP10.1; also elsewhere on the board
/GW5A_LV25MG121N/DBGIO.RTCK: J2.30, TP7.1; also elsewhere on the board
/GW5A_LV25MG121N/DBGIO.SRST_I: J2.24, TP11.1; also elsewhere on the board
/GW5A_LV25MG121N/DBGIO.SRST_O: J2.20, TP12.1; also elsewhere on the board
/GW5A_LV25MG121N/DBGIO.TCK: J2.18, TP1.1; also elsewhere on the board
/GW5A_LV25MG121N/DBGIO.TDI: J2.16, TP6.1; also elsewhere on the board
/GW5A_LV25MG121N/DBGIO.TDO: J2.14, TP5.1; also elsewhere on the board
/GW5A_LV25MG121N/DBGIO.TMS_I: J2.12, TP4.1; also elsewhere on the board
/GW5A_LV25MG121N/DBGIO.TMS_O: J2.8, TP3.1; also elsewhere on the board
/GW5A_LV25MG121N/DBGIO.TMS_T: J2.10, TP2.1; also elsewhere on the board
/GW5A_LV25MG121N/DBGIO.TRST_I: J2.26, TP13.1; also elsewhere on the board
/GW5A_LV25MG121N/DBGIO.TRST_O: J2.22, TP14.1; also elsewhere on the board
/GW5A_LV25MG121N/DBGIO.UART_RX: J2.28, TP9.1; also elsewhere on the board
/GW5A_LV25MG121N/DBGIO.UART_TX: J2.6, TP8.1; also elsewhere on the board
/GW5A_LV25MG121N/E1_IOB12B_40P: J2.15
/GW5A_LV25MG121N/E3_IOB60A_40P: J1.23
/GW5A_LV25MG121N/E8_READY: J1.17, R35.2
/GW5A_LV25MG121N/E10_IOL3B: J1.54
/GW5A_LV25MG121N/E11_IOL3A: J1.52
/GW5A_LV25MG121N/F1_IOB26B_40P: J2.9
/GW5A_LV25MG121N/F2_IOB26A_40P: J2.7
/GW5A_LV25MG121N/F5_IOT72A: J1.20
/GW5A_LV25MG121N/F6_IOT58B_40P: J1.13; also elsewhere on the board
/GW5A_LV25MG121N/F7_IOT58A_40P: J1.11; also elsewhere on the board
/GW5A_LV25MG121N/G5_IOT72B: J1.22
/GW5A_LV25MG121N/G7_IOT68A: J1.16
/GW5A_LV25MG121N/G8_IOT68B: J1.18
/GW5A_LV25MG121N/H1_IOB91A_40P: J2.34
/GW5A_LV25MG121N/H2_IOB91B_40P: J2.36
/GW5A_LV25MG121N/H5_IOT61A: J1.4, R38.2
/GW5A_LV25MG121N/H7_IOT66B: J1.14
/GW5A_LV25MG121N/H8_IOT66A: J1.12
/GW5A_LV25MG121N/H11_IOT3A_S1: J1.37
/GW5A_LV25MG121N/J5_IOT61B: J1.6, R37.2
/GW5A_LV25MG121N/J8_IOT56A_40P: J1.7
/GW5A_LV25MG121N/J10_IOT1B_40P: J1.35
/GW5A_LV25MG121N/J11_IOT1A_40P: J1.33
/GW5A_LV25MG121N/K5_IOT63B: J1.10
/GW5A_LV25MG121N/K8_IOT56B_40P: J1.9
/GW5A_LV25MG121N/K9_MCU_SWC: J1.5, J6.8
/GW5A_LV25MG121N/L5_IOT63A: J1.8, R36.2
/GW5A_LV25MG121N/L9_MCU_SWD: J1.3, J6.7
/GW5A_LV25MG121N/M0_CK_N: J2.45
/GW5A_LV25MG121N/M0_CK_P: J2.43
/GW5A_LV25MG121N/M0_D0_N: J2.57
/GW5A_LV25MG121N/M0_D0_P: J2.55
/GW5A_LV25MG121N/M0_D1_N: J2.51
/GW5A_LV25MG121N/M0_D1_P: J2.49
/GW5A_LV25MG121N/M0_D2_N: J2.39
/GW5A_LV25MG121N/M0_D2_P: J2.37
/GW5A_LV25MG121N/M0_D3_N: J2.33
/GW5A_LV25MG121N/M0_D3_P: J2.31
/GW5A_LV25MG121N/ULPI.CLK: J1.39; also elsewhere on the board
/GW5A_LV25MG121N/ULPI.DATA0: J1.44; also elsewhere on the board
/GW5A_LV25MG121N/ULPI.DATA1: J1.42; also elsewhere on the board
/GW5A_LV25MG121N/ULPI.DATA2: J1.40; also elsewhere on the board
/GW5A_LV25MG121N/ULPI.DATA3: J1.38; also elsewhere on the board
/GW5A_LV25MG121N/ULPI.DATA4: J1.36; also elsewhere on the board
/GW5A_LV25MG121N/ULPI.DATA5: J1.34; also elsewhere on the board
/GW5A_LV25MG121N/ULPI.DATA6: J1.32; also elsewhere on the board
/GW5A_LV25MG121N/ULPI.DATA7: J1.30; also elsewhere on the board
/GW5A_LV25MG121N/ULPI.DIR: J1.48; also elsewhere on the board
/GW5A_LV25MG121N/ULPI.NXT: J1.46; also elsewhere on the board
/GW5A_LV25MG121N/ULPI.RESETB: J1.43; also elsewhere on the board
/GW5A_LV25MG121N/ULPI.STP: J1.41; also elsewhere on the board
/GW5A_LV25MG121N/VCCIO0/1: FB1.1, J1.24, J1.26
/GW5A_LV25MG121N/VCCIO2/3: FB2.1, J2.2, J2.4
/GW5A_LV25MG121N/VCCIO6/7: FB3.1, J1.29, J1.31
GND: D4.1 (K), D5.1 (K), J1.1, J1.2, J1.15, J1.27, J1.28, J1.45, J1.50, J1.59, J1.60, J2.1, J2.19, J2.29, J2.35, J2.41, J2.47, J2.53, J2.59, J6.6, R6.2; also elsewhere on the board
unnamed: D4.2 (A), R34.1
unnamed: D5.2 (A), R35.1
unnamed: D6.3 (BK), R38.1
unnamed: D6.2 (GK), R37.1
unnamed: D6.1 (RK), R36.1

Notes on the sheet:
GCLK
BANK3
Core Board Connector
Input
BANK6
3.3V
Output
BANK0
BANK7
BANK5
RPLL
BANK2
BANK1
BANK10
BANK4
MIPI DPHY HardCore

Parts:
C6, C7, C13, C14: 4.7uF,10V; C_0402_1005Metric
C8, C11, C33: 2.2nF,50V; C_0402_1005Metric
C9: 10pF,50V; C_0402_1005Metric
C10: 10nF,50V; C_0402_1005Metric
C12, C15, C16, C17, C18, C19, C20, C21, C22, C23, C24, C25, C26, C27, C28, C30, C31, C32: 100nF,16V; C_0402_1005Metric
FB4: 600Ω@100MHz; L_0402_1005Metric
J3: Conn_ARM_JTAG_SWD_20; IDC-Header_2x10_P2.54mm_Horizontal
J5: WAFER-ZH1.5-4PWB; ZH_SM04_1.50mm_Horizontal
Q1: SI2305; SOT-23-3
R7, R18, R20, R28, R40, R41, R42, R44, R45, R46: 33R,1%; R_0402_1005Metric
R17: 100mR,1%,1W; R_1206_3216Metric
R19, R21, R22, R25, R26, R27, R32, R39, R47, R48: 10K,1%; R_0402_1005Metric
R23, R24: 1K,1%; R_0402_1005Metric
R29, R30, R31, R33: 4.7K,1%; R_0402_1005Metric
R43: 100K,1%; R_0402_1005Metric
TP15: test_point_0.5mm
U3, U10, U11: SN74LVC1G125DCK; Texas_R-PDSO-G5_DCK-5
U4, U5, U6, U7, U9, U12, U13: SN74LVC2T45DCUR; VSSOP-8_2.3x2mm_P0.5mm
U8: MT9700; SOT-23-5
U14: ADS1115IDGS; TSSOP-10_3x3mm_P0.5mm
U15: LMV358; SOIC-8_3.9x4.9mm_P1.27mm

Connections:
+3V3: C15.2, C16.2, C17.2, C18.2, C19.2, C20.2, C21.2, FB4.2, R30.2, R31.2, U4.1 (VCCA), U5.1 (VCCA), U5.5 (DIR), U6.1 (VCCA), U6.5 (DIR), U7.1 (VCCA), U7.5 (DIR), U9.1 (VCCA), U12.1 (VCCA), U13.1 (VCCA), U13.5 (DIR); also elsewhere on the board
+5V: C7.1, C13.1, Q1.2 (S), R47.1, U8.5 (VIN), U15.8 (V+); also elsewhere on the board
/GW5A_LV25MG121N/DBGIO.PWR: U8.4 (EN); also elsewhere on the board
/GW5A_LV25MG121N/DBGIO.RTCK: U12.2 (A1); also elsewhere on the board
/GW5A_LV25MG121N/DBGIO.SRST_I: U9.3 (A2); also elsewhere on the board
/GW5A_LV25MG121N/DBGIO.SRST_O: U6.3 (A2); also elsewhere on the board
/GW5A_LV25MG121N/DBGIO.TCK: U5.2 (A1); also elsewhere on the board
/GW5A_LV25MG121N/DBGIO.TDI: U5.3 (A2); also elsewhere on the board
/GW5A_LV25MG121N/DBGIO.TDO: U4.2 (A1); also elsewhere on the board
/GW5A_LV25MG121N/DBGIO.TMS_I: U4.3 (A2); also elsewhere on the board
/GW5A_LV25MG121N/DBGIO.TMS_O: U7.3 (A2); also elsewhere on the board
/GW5A_LV25MG121N/DBGIO.TMS_T: U7.2 (A1); also elsewhere on the board
/GW5A_LV25MG121N/DBGIO.TRST_I: U9.2 (A1); also elsewhere on the board
/GW5A_LV25MG121N/DBGIO.TRST_O: U6.2 (A1); also elsewhere on the board
/GW5A_LV25MG121N/DBGIO.UART_RX: U12.3 (A2); also elsewhere on the board
/GW5A_LV25MG121N/DBGIO.UART_TX: U13.3 (A2); also elsewhere on the board
/GW5A_LV25MG121N/F6_IOT58B_40P: R30.1, U14.9 (SDA); also elsewhere on the board
/GW5A_LV25MG121N/F7_IOT58A_40P: R31.1, U14.10 (SCL); also elsewhere on the board
/INTERFACE/IOUT_ADC: C8.1, R28.2, U14.5 (AIN1)
/INTERFACE/RTCK: J3.11 (RTCK), R44.2
/INTERFACE/SRST: J3.15 (~SRST), R33.1, U9.6 (B2), U11.4
/INTERFACE/SRST_O: U6.6 (B2), U11.1
/INTERFACE/TCK: J3.9 (TCK/SWCLK), R40.2
/INTERFACE/TDI: J3.5 (TDI), R41.2
/INTERFACE/TDO: J3.13 (TDO/SWO), R46.2
/INTERFACE/TMS: J3.7 (TMS/SWDIO), R7.2
/INTERFACE/TMS_O: U3.2, U7.6 (B2)
/INTERFACE/TMS_T: U3.1, U7.7 (B1)
/INTERFACE/TRST: J3.3 (~TRST), R29.1, U9.7 (B1), U10.4
/INTERFACE/TRST_O: U6.7 (B1), U10.1
/INTERFACE/UART_RX: J3.17 (DBGRQ/NC), J5.3, R39.2, R45.2
/INTERFACE/UART_TX: J5.2, R42.2
/INTERFACE/VBUS_ADC: C33.1, R47.2, R48.1, U14.6 (AIN2)
/INTERFACE/VTREF_ADC: C11.1, R26.2, R27.1, U14.4 (AIN0)
GND: C6.2, C7.2, C8.2, C11.2, C12.2, C13.2, C14.2, C15.1, C16.1, C17.1, C18.1, C19.1, C20.1, C21.1, C22.1, C23.1, C24.1, C25.1, C26.1, C27.1, C28.1, C30.1, C31.1, C32.1, C33.2, J3.4 (GND), J3.6 (GND), J3.8 (GND), J3.10 (GND), J3.12 (GND), J3.14 (GND), J3.16 (GND), J3.18 (GND), J3.20 (GND), J5.4, J5.MP (MountPin), R25.2, R27.2, R32.2, R43.1, R48.2, U3.3 (GND), U4.4 (GND), U4.5 (DIR), U5.4 (GND), U6.4 (GND), U7.4 (GND), U8.2 (GND), U9.4 (GND), U9.5 (DIR), U10.2, U10.3 (GND), U11.2, U11.3 (GND), U12.4 (GND), U12.5 (DIR), U13.2 (A1), U13.4 (GND), U14.1 (ADDR), U14.3 (GND), U15.4 (V-); also elsewhere on the board
unnamed: C9.1, C10.1, R18.1, U15.1
unnamed: C10.2, R19.2
unnamed: J3.19 (DBGACK/NC), R17.2, R23.1
unnamed: Q1.1 (G), R18.2
unnamed: R22.2, R28.1, U15.7
unnamed: R46.1, U4.7 (B1)
unnamed: R7.1, U3.4, U4.6 (B2)
unnamed: R40.1, U5.7 (B1)
unnamed: R41.1, U5.6 (B2)
unnamed: R32.1, U8.3 (SET)
unnamed: C14.1, R17.1, R24.1, U8.1 (VOUT)
unnamed: R44.1, U12.7 (B1)
unnamed: R45.1, U12.6 (B2)
unnamed: R42.1, U13.6 (B2)
unnamed: C12.1, FB4.1, U14.8 (VDD)
unnamed: R20.1, U15.3 (+)
unnamed: C9.2, R19.1, R21.2, U15.2 (-)
unnamed: R24.2, R25.1, U15.5 (+)
unnamed: R22.1, R23.2, U15.6 (-)
VTARG: C6.1, C22.2, C23.2, C24.2, C25.2, C26.2, C27.2, C28.2, C30.2, C31.2, C32.2, Q1.3 (D), R20.2, R26.1, R29.2, R33.2, R39.1, TP15.1, U3.5 (VCC), U4.8 (VCCB), U5.8 (VCCB), U6.8 (VCCB), U7.8 (VCCB), U9.8 (VCCB), U10.5 (VCC), U11.5 (VCC), U12.8 (VCCB), U13.8 (VCCB)
VTREF: J3.1 (VTREF), J5.1, R21.1, R43.2

Notes on the sheet:
延迟敏感，不要买友台的

Parts:
C1, C2, C3, C4: 100nF,16V; C_0402_1005Metric
C5, C29: 4.7uF,10V; C_0402_1005Metric
F1: SMD0603-050-6; Fuse_0603_1608Metric
J4: USB_C_Receptacle_USB2.0_16P; USB_C_Receptacle_HRO_TYPE-C-31-M-12
R1: 10K,1%; R_0402_1005Metric
R2: 1K,1%; R_0402_1005Metric
R3: 8.06K,1%; R_0402_1005Metric
R4, R5: 5.1K,1%; R_0402_1005Metric
R8, R11: 0R,1%; R_0402_1005Metric; not fitted
R9, R10, R12, R13, R14, R15, R16: 0R,1%; R_0402_1005Metric
U1: ECMF02-2AMX6; ST_UQFN-6L_1.5x1.7mm_P0.5mm
U2: USB3320C-EZK; QFN-32-1EP_5x5mm_P0.5mm_EP3.1x3.1mm

Connections:
+1V8: C1.1, R9.2, R12.1, R13.1, R14.1, R15.2, R16.2, U2.32 (VDDIO); also elsewhere on the board
+3V3: C4.1, C5.1, R1.1, U2.20 (VDD33), U2.21 (VBAT); also elsewhere on the board
+5V: C29.1, F1.2, R2.1; also elsewhere on the board
/GW5A_LV25MG121N/ULPI.CLK: R8.1, R10.1; also elsewhere on the board
/GW5A_LV25MG121N/ULPI.DATA0: U2.3 (DATA0); also elsewhere on the board
/GW5A_LV25MG121N/ULPI.DATA1: U2.4 (DATA1); also elsewhere on the board
/GW5A_LV25MG121N/ULPI.DATA2: U2.5 (DATA2); also elsewhere on the board
/GW5A_LV25MG121N/ULPI.DATA3: U2.6 (DATA3); also elsewhere on the board
/GW5A_LV25MG121N/ULPI.DATA4: U2.7 (DATA4); also elsewhere on the board
/GW5A_LV25MG121N/ULPI.DATA5: U2.9 (DATA5); also elsewhere on the board
/GW5A_LV25MG121N/ULPI.DATA6: U2.10 (DATA6); also elsewhere on the board
/GW5A_LV25MG121N/ULPI.DATA7: U2.13 (DATA7); also elsewhere on the board
/GW5A_LV25MG121N/ULPI.DIR: U2.31 (DIR); also elsewhere on the board
/GW5A_LV25MG121N/ULPI.NXT: U2.2 (NXT); also elsewhere on the board
/GW5A_LV25MG121N/ULPI.RESETB: U2.27 (RESETB); also elsewhere on the board
/GW5A_LV25MG121N/ULPI.STP: U2.29 (STP); also elsewhere on the board
/USB3320/D+: U1.6 (D+), U2.18 (DP)
/USB3320/D-: U1.5 (D-), U2.19 (DM)
/USB3320/USB_D+: J4.A6 (D+), J4.B6 (D+), U1.1 (D+)
/USB3320/USB_D-: J4.A7 (D-), J4.B7 (D-), U1.2 (D-)
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C29.2, J4.A1 (GND), J4.A12 (GND), J4.B1 (GND), J4.B12 (GND), J4.S1 (SHIELD), R3.1, R4.1, R5.1, R11.2, U1.3 (GND), U2.33 (GND); also elsewhere on the board
unnamed: C2.1, R15.1, U2.28 (VDD18)
unnamed: C3.1, R16.1, U2.30 (VDD18)
unnamed: F1.1, J4.A4 (VBUS), J4.A9 (VBUS), J4.B4 (VBUS), J4.B9 (VBUS)
unnamed: J4.A5 (CC1), R5.2
unnamed: J4.B5 (CC2), R4.2
unnamed: R8.2, R9.1, U2.1 (CLKOUT)
unnamed: R1.2, U2.23 (ID)
unnamed: R3.2, U2.24 (RBIAS)
unnamed: R10.2, R11.1, U2.26 (REFCLK)
unnamed: R12.2, U2.8 (REFSEL0)
unnamed: R13.2, U2.11 (REFSEL1)
unnamed: R14.2, U2.14 (REFSEL2)
unnamed: R2.2, U2.22 (VBUS)

Notes on the sheet:
CH132B 不焊
CH132B 0R
CH132B 不焊R1 R2
R9 R10 USB3320 R8 R11 CH132B

Board: 4 copper layers, 48.5 x 33.5 mm, 130 parts (96 on the bottom side), 106 nets.

## Commit log

2025-12-12 init
2025-12-13 spiflash部分调通，bootloader和下载算法均有问题
2025-12-13 app改回itcm内存
2025-12-15 重构USB外设，将端点0部分命令转至mcu处理，已实现OUT方向
2025-12-17 修改USB中断控制逻辑
2025-12-21 加回USB硬件DESC功能，调试软件已能识别USB设备，WCID正常
2025-12-21 新增串口功能，当前仅支持发送，M1软核关闭iic开启定时器外设，开启GPIO外设，开启APB1总线接口
2025-12-22 串口发送支持USB配置和数据，校验位停止位修复bug验证成功
2025-12-27 支持串口接收
2025-12-28 DAP框架搭建，部分实现info命令
2026-01-01 DAP支持ExecuteCommands命令，补全指令解码，测试delay命令
2026-01-03 将DAP数据返回断点改为邮箱模式，避免USB粘包，补充DAP软件协议实现
2026-01-03 DAP新增GPIO模块和波特率发生器模块
2026-01-04 修改时序约束，DAP忽略07命令，GPIO iodelay不可行
2026-01-10 上传PCB，修改芯片型号为GW5A-LV25MG121NC1/I0
2026-01-10 修正串口线序
2026-01-14 PCB修改器件干涉问题，更换LED
2026-01-18 移植到新硬件
    【PCB】输出端口串联33欧电阻，螺丝孔接地，串口RX上拉
    【RTL】引脚适配，重构GPIO
    【MCU】支持1115读取电压电流
2026-01-18 重构USB发送缓冲器，SWJ模块，阶段性上传
2026-01-18 修复综合报错，优化DAPCMD编码
2026-01-19 修复bug，DAP功能恢复到重构前状态
2026-01-22 补全PCB3D模型
2026-01-24 搭建时序框架，支持DAP_SWJ_Sequence功能
2026-01-25 优化跨时钟域操作，命令间隔降低到104ns
2026-02-01 实现SWD_SEQ命令，删除SEQ_CMD_SWJ_SEQ命令，使用SWD_SEQ命令替代
2026-02-01 修buf，上传测试脚本代码
2026-02-07 支持swj pins命令
2026-02-09 替换DAP USB接收实现修复高云USB BUG；TCK delay调整；部分v代码优化
2026-02-10 修复部分小bug，补全工程文件和忽略配置文件
2026-02-11 补testbench
2026-02-13 支持DAP_SWD_TransferBlock，未测试
2026-02-14 编写testbench；修改DAP波特率生成器支持更大范围的采样点配置，修复bug
2026-02-14 修改接收移位
2026-02-16 重构SWD时序
2026-02-16 testbench支持同步调整turn周期；修复SWD读操作末尾turn时未清除的bug；修复赋值错误bug
2026-02-17 支持DAP_Transfer命令，seq部分时序有问题
2026-02-18 修改swd时序参数传递方式，修改swd时序bug，修改swd block命令状态机为独热码编码，逐步移除buf64依赖
2026-02-18 重构DAP_Controller和相关模块，移除us_timer和us_tick，改为使用clk_timer，优化时序逻辑
2026-02-18 修改SWD、SWJ Seq命令操作，改为一次传输8b减小综合时序压力，同时取消并行状态机，因为只读一个字节影响并不大。 删除buf64公共逻辑 修改seq_tx变量操作方式，减少组合逻辑和寄存器开销
2026-02-18 减小seq通信位宽，降低时序压力
2026-02-19 支持swd abort命令，修复时序问题和状态机赋值bug
2026-02-20 上机调试，修复swj pins状态机赋值错误，修复swd采样时刻提前一周期，MCU程序适配时序和重试配置，ocd读取芯片ID正常，写内存有错误
2026-02-20 修复swd_trans判断条件未覆盖完全导致命令卡死问题，修复swd_block_trans状态机赋值错误 openocd实测30M时钟下能达到1.8MB/s速度
2026-02-21 swd修复反馈状态位错误，mask在第四位，swd协议错误在第三位；测试脚本支持swd切换时序和读芯片ID
2026-02-22 重构DAP USB Packer，修复发送一帧接近512字节的大帧后后续数据错乱问题
2026-02-22 修复transfer block命令在读AP寄存器时错误状态转移提前退出问题
2026-02-22 mcu程序支持从flash读取唯一ID作为序列号，cmake支持合并比特流生成bin文件
2026-02-23 FPGA修改turn位宽，增加data phase支持 MCU支持配置命令，支持在线升级
2026-02-23 MCU支持transfer参数配置
2026-02-26 修复USB连续发包时包头和上一包包尾重叠问题；修复block transfer在读一个AP时死循环问题和错误处理异常
2026-02-26 修复USB在PC连续读DAP端点时数据异常问题
2026-02-26 注释ads1115_i2c_init防止升级卡死，修改打包脚本在fpga启用ila时找不到posp文件的问题，修改DAP能力为当前已支持的功能
2026-02-26 修复block transfer多传一个的bug
2026-03-08 修改USB描述符驱动改为FPGA实现，解决部分电脑发送IN请求太快软核响应不及时导致的不识别USB的问题
2026-03-09 修改USB描述符解决pyocd不识别问题
2026-03-11 修改SWD MODE标志电平，默认启用SWD和独立串口模式，裁剪MCU RAM
2026-03-17 整理ADC代码，支持读取电压并进行简单LED控制
2026-03-19 修复Abort指令卡死问题
2026-04-05 支持60M时钟 修改波特率发生器，增加延迟寄存器 修改SWD时序，turn段周期大于1时可选只产生第一个时钟
2026-04-05 修复BUG
2026-04-06 支持上位机配置参数
2026-04-06 更新readme
2026-04-07 移除easyflash和无用的模块，替换为更简单稳定的实现
2026-04-08 修复USB在发送512长度包时实际发送空包的bug，原因是长度字段位数少1位溢出了
2026-04-19 整理SWJ控制器逻辑，拆分always块，添加部分JTAG实现，阶段备份
2026-04-19 添加部分JTAG命令实现，JTAG时序还需要重构将IR操作包含在每个命令内
2026-04-19 SWJ去除IR相关逻辑，时序模块拆分always
2026-04-19 删除JTAG IR相关命令，后续移动到各自命令内
2026-04-20 jtag编码完成，待测
2026-04-21 修改jtag时序，seq命令可用，trans异常；swd命令会出现异常校验错误可能和swdio高阻引脚有关
2026-04-21 feat(FPGA): add build.ninja for DAP_JTAG_Transfer testbench
2026-04-22 修复SWD校验位错误BUG 修复JTAG模式下命令异常卡死BUG jtag时序差异还需读手册
2026-04-23 修复DAP控制器命令编码并简化JTAG Sequence包长度计算
    - 重新分配SEQ_CMD_SWD_SEQ和SEQ_CMD_JTAG_SEQ命令编码
    - 移除jtag_seq_packet_len寄存器，改用jtag_seq_ram_write_addr直接计算包长度
    - 修正JTAG IDCODE传输命令格式
2026-04-24 修正JTAG ACK字段编码
2026-04-26 修改transfer和transfer状态机，补充SWD写DP操作RDBUFF确认操作，支持JTAG模式POST READ功能 keil测试SWD通过，JTAG依然报错
2026-04-26 JTAG测试通过 修改JTAG transfer block 读AP操作收尾RDBUFF命令缺失IR标志的bug 修改JTAG seq命令位序错误bug 修改时序默认参数tdi增加750ps延迟 修改测试脚本jtag seq命令计算错误
2026-05-01 更换一个资源占用更小的SPI外设，支持LED PWM调光和两种模式控制
2026-05-02 支持串口break信号
2026-05-03 新增时序自动测量功能，发现SWD频率无法正常跑到60M
2026-05-04 修复时钟无法达到60M问题
2026-05-04 Seqence JTAG模式下全程驱动TMS信号，防止高阻信号乱飘，修改jtag seq采样时刻
2026-05-04 [PCB] vtrg增加100K下拉电阻
2026-05-05 添加DAP Vendor1接口支持SPI Flash操作
2026-05-10 添加SWO调试接口及优化综合实现配置
2026-05-14 PCB JTAG每个信号都增加33欧串阻，USB供电电压传感
2026-05-16 支持SWO Trace功能
2026-05-17 Keil会轮询SWO Status命令，改为硬件实现加速
2026-05-19 SWO：修复使能后丢第一个边沿的问题；修复注入波特率误差并优化时序计算
2026-05-24 新增支持清除和数据数量输出功能的usb fifo实现 替换SWO的fifo swo status使用实际的fifo数据量实现
2026-05-30 修复USB_Transfer中EP没有切换连续发送时异常重复发送的BUG 删除多余文件 优化串口 FPGA源文件头部添加timescale
2026-05-31 修改ADC代码，增加5V电压读取，当电压低于1.2V时DAP不允许链接
2026-06-13 目标电压阈值修改到1.65V，支持版本号构建时间命令
2026-06-17 更新readme文档：修正下载速度为3867KB/s，更新支持目标电压为1.65V-5V
2026-06-20 修复SWD传输中时钟控制与三态逻辑：读操作正输出时钟数量，正确驱动turn高阻态 优化时序约束
